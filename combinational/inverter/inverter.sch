v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
L 4 1340 -890 1340 -870 {}
L 4 1340 -810 1340 -790 {}
L 4 1340 -730 1340 -710 {}
L 4 1280 -840 1300 -840 {}
L 4 1280 -840 1280 -760 {}
L 4 1280 -760 1300 -760 {}
L 4 1260 -800 1280 -800 {}
L 4 1340 -800 1360 -800 {}
L 4 1340 -910 1340 -890 {}
L 4 1340 -710 1340 -690 {}
C {title-3.sym} -100 -20 0 0 {name=l5 author="Andrew Chen" rev=1.0 lock=false}
C {nmos.sym} 1320 -760 0 0 {name=M1 model=M2N7002 device=2N7002 footprint=SOT23 m=1}
C {pmos.sym} 1320 -840 0 0 {name=M2 
model=DMP2035U 
device=DMP2035U 
m=1}
C {opin.sym} 1360 -800 0 0 {name=p1 lab=Vout
}
C {ipin.sym} 1260 -800 0 0 {name=p2 lab=Vin
}
C {iopin.sym} 1340 -910 3 0 {name=p3 lab=xxx}
C {iopin.sym} 1340 -690 1 0 {name=p4 lab=xxx}
